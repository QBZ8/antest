# Keil uVision project 89LV51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(33000000) MODAT2
  output: 89LV51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\BAO\copy\24L01\新版24L01\source code new\24L01 source code\
  group Source Group 1
    ./: 89lv51.c
